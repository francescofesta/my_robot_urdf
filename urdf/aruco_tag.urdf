Commit message: aruco_detection
funzionante

File: urdf/aruco_tag.urdf (robot description, URDF)
Before this commit: robot ar_2020, 1 links, 0 joints
Links:
- link simple_box_base_link: geometry collision box size=0.2 0.2 0.2; visual mesh filename=package://my_robot_urdf/meshes/mesh101.dae
