Commit message: spawn_AR non funzionante

File: urdf/AR_tag.urdf (robot description, URDF)
Before this commit: robot ar_2020, 1 links, 0 joints
Links:
- link simple_box_base_link: geometry collision box size=0.2 0.2 0.2; visual mesh filename=meshes/ar_mesh.dae
